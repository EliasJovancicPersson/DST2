# IAR project Projekt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8E Atmel SAM3X8E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Projekt.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\Users\elijov23\Desktop\Projekt_DST2\sam3x8-sram_BigHeap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: at91sam3x8.h context_switching_functions_march_2019.s core_cm3.h core_cmFunc.h core_cmInstr.h cstartup.s startup_sam3x.c system_sam3x.c system_sam3x.h
  group C files
    ./: compare.c exceptions.c kernel_functions.c linkedList.c mailboxList.c main.c
  group H files
    ./: exceptions.h kernel_functions.h linkedList.h mailboxList.h
